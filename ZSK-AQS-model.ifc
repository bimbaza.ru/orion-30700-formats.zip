Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:18:54+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-AQS
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Оборудование благоустройства, ZSK-AQS AQUA SWING · сухой фонтан с качелями
In: Площадка
Description: Оборудование благоустройства. AQUA SWING · сухой фонтан с качелями; Classification: 59.1.15.01-0413 Качели (Классификатор строительных ресурсов (КСР))
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-AQS; ModelReference: AQUA SWING · сухой фонтан с качелями; ProductionYear: 2026; ArticleNumber: ZSK-AQS
ORION_Изделие - Артикул: ZSK-AQS; Артикул прежний: SD-AQS; Наименование: AQUA SWING · сухой фонтан с качелями; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: Ø 8 000–10 000 × 4 000 мм; Возраст: дети от 3 лет и взрослые; Цена: от 5 600 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/aqua-swing/30700; Код КСИ: CPr>EDB070; Класс КСИ: Качели; Коды КСР: 59.1.15.01-0413 … 59.1.15.01-0469
ADSK - ADSK_Наименование: AQUA SWING · сухой фонтан с качелями; ADSK_Марка: ZSK-AQS; ADSK_Код изделия: 59.1.15.01-0413; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_URL страницы изделия: https://зск.рф/catalog/aqua-swing/30700
ZSK_Благоустройство - ZSK_Возрастная_группа: дети от 3 лет и взрослые; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB070; ZSK_Артикул_прежний: SD-AQS
Qto_ORION - Длина: 8 mm; Ширина: 8 mm; Высота: 0 mm
